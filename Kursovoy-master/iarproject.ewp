# IAR project iarproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Rtos; Rtos\wrapper; Rtos\wrapper\FreeRtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable; Rtos\FreeRtos\portable\Common; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\FreeRtos\portable\MemMang; MyTasks; Common; CMSIS; Application; Application\Diagnostic; AHardware; AHardware\GpioPort; AHardware\IrqController; ..\CortexLib\AbstractHardware\Pin; ..\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; ..\CortexLib\AbstractHardware\Registers\STM32F411; ..\CortexLib\AbstractHardware\Registers; ..\CortexLib\AbstractHardware\Port; ..\CortexLib\AbstractHardware\Atomic; ..\CortexLib\Common; ..\CortexLib\Common\Singleton; ..\CortexLib\AbstractHardware\Spi; AHardware; ..\CortexLib\Common; MyTask; AHardware\Fonts
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\wrapper\FreeRtos; Rtos\wrapper
  OBJCOPY.OOCOutputFile: iarproject.srec
  ILINK.IlinkOutputFile: iarproject.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp startupF411RE.cpp
  group AHardware
    AHardware/: DislpayDriver.hpp DisplayView.hpp EInkDisplay.hpp Format.hpp GpioPort.hpp IDisplay.hpp IDisplayDriver.hpp IDisplayView.hpp IGpio.hpp Pinsconfig.hpp SMBus.hpp SPI.hpp USART.hpp USARTConfig.hpp
  group AHardware/Fonts
    AHardware/Fonts/: font12.c font12CN.c font16.c font20.c font24.c font24CN.c font8.c fonts.h
  group Application
    Application/: Bluetooth.hpp BluetoothDriver.hpp Button.hpp ButtonTask.hpp Celsuis.hpp DisplayDirector.hpp Fahrenheit.hpp Filter.hpp IBluetoothDriver.hpp ImyEvent.hpp IUnits.hpp IVariable.hpp Kelvin.hpp Measuring.hpp Temperature.hpp TemperatureDirector.hpp TemperatureSensor.hpp TemperatureTask.hpp
  group MyTask
    MyTask/: BluetoothDirector.cpp BluetoothDirector.hpp DisplayDirector.cpp TemperatureTask.cpp
    Application/: ButtonTask.cpp
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/portable/Common
    Rtos/FreeRtos/portable/Common/: mpu_wrappers.c
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.c portasm.s
  group Rtos/FreeRtos/portable/MemMang
    Rtos/FreeRtos/portable/MemMang/: heap_1.c
